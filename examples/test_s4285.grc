options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    thread_safe_setters: '1'
  states: {}

blocks:
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (4,0,1,1)
    label: '"STANAG4285 mode"'
    labels: '[]'
    num_opts: '0'
    options: '[''2400/L'', ''1200/L'', ''600/L'', ''300/L'', ''150/L'', ''75/L'', ''2400/S'', ''1200/S'', ''600/S'', ''300/S'', ''150/S'', ''75/S'']'
    type: string
    value: '''600/L'''
  states: {}
- name: nB
  id: variable
  parameters:
    value: '8'
  states: {}
- name: nF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: nW
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: samp_rate_0
  id: variable_function_probe
  parameters:
    block_id: wavfile_source_block
    function_name: sample_rate
    poll_rate: '10'
    value: '12000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '10e-3'
    decay_rate: '10e-3'
    gain: '1'
    max_gain: '50'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bits.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/5*sps
    type: complex
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 12001.0/12000*5.0/sps
    type: complex
  states: {}
- name: qt_pysical_layer_0
  id: qt_pysical_layer
  parameters:
    frame_len_bits: '64'
    frame_len_symb: '256'
    nB: nB
    nF: nF
    nW: nW
    physical_layer_mode: mode
    physical_layer_type: '''STANAG_4285'''
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: wavfile_source_block
  id: blocks_wavfile_source
  parameters:
    file: /home/cmayer/Downloads/kphsdr.com_2019-09-10T06_10_22Z_4272.80_iq.wav
    nchan: '2'
    repeat: 'False'
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', mmse_resampler_xx_0, '0']
- [blocks_throttle_0, '0', qt_pysical_layer_0, '0']
- [mmse_resampler_xx_0, '0', analog_agc2_xx_0, '0']
- [qt_pysical_layer_0, '0', blocks_file_sink_0, '0']
- [qt_pysical_layer_0, '1', blocks_null_sink_0, '0']
- [qt_pysical_layer_0, '2', blocks_null_sink_1, '0']
- [wavfile_source_block, '0', blocks_float_to_complex_0, '0']
- [wavfile_source_block, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
