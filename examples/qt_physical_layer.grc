options:
  parameters:
    category: '[digitalhf]'
    description: physical_layer_driver + QT interface
    generate_options: hb_qt_gui
    id: qt_pysical_layer
    output_language: python
    thread_safe_setters: '1'
    title: QT physical layer driver
  states: {}

blocks:
- name: doppler
  id: variable_function_probe
  parameters:
    block_id: digitalhf_physical_layer_driver_0
    function_name: get_doppler
    poll_rate: '5'
    value: '''UNKNOWN'''
  states: {}
- name: frame_len_bits_range
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@4:1,0,1,1
    label: frame length
    orient: Qt.Horizontal
    rangeType: int
    start: '2'
    step: '1'
    stop: '4096'
    value: frame_len_bits
  states: {}
- name: label_doppler
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: Doppler
    type: string
    value: doppler
  states: {}
- name: label_mode
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,4
    label: Mode
    type: raw
    value: mode_for_display
  states: {}
- name: label_quality
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,5,1,1
    label: Quality
    type: string
    value: quality
  states: {}
- name: mode_for_display
  id: variable_function_probe
  parameters:
    block_id: digitalhf_physical_layer_driver_0
    function_name: get_mode
    poll_rate: '5'
    value: '"____"'
  states: {}
- name: mu
  id: variable_qtgui_range
  parameters:
    gui_hint: (4,0,1,3)
    label: mu
    orient: Qt.Horizontal
    start: '0.0001'
    step: '0.0001'
    stop: '0.01'
    value: '0.01'
  states: {}
- name: quality
  id: variable_function_probe
  parameters:
    block_id: digitalhf_physical_layer_driver_0
    function_name: get_quality
    poll_rate: '5'
    value: '''UNKNOWN'''
  states: {}
- name: bits_msg_sink
  id: pad_sink
  parameters:
    label: bits_msg
    optional: 'True'
    type: message
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.4'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: exp(0.4j)
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: (1+(nB+nF)*sps)
    type: complex
  states: {}
- name: digitalhf_physical_layer_driver_0
  id: digitalhf_physical_layer_driver
  parameters:
    alpha: '0.1'
    description_name: physical_layer_type
    mode: physical_layer_mode
    mu: mu
    nB: nB
    nF: nF
    nW: nW
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: frame_len_bits
  id: parameter
  parameters:
    label: frame length bits
    type: intx
    value: '64'
  states: {}
- name: frame_len_symb
  id: parameter
  parameters:
    label: frame length  symbols
    type: intx
    value: '256'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from numpy import exp, pi
  states: {}
- name: nB
  id: parameter
  parameters:
    label: nB
    type: intx
    value: '9'
  states: {}
- name: nF
  id: parameter
  parameters:
    label: nF
    type: intx
    value: '9'
  states: {}
- name: nW
  id: parameter
  parameters:
    label: nW
    type: intx
    value: '9'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: bits
    type: byte
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: symbols
    type: complex
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: soft_dec
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: I/Q input
    type: complex
  states: {}
- name: physical_layer_mode
  id: parameter
  parameters:
    label: mode for physical layer
    type: str
    value: '"600/L"'
  states: {}
- name: physical_layer_type
  id: parameter
  parameters:
    label: Type of physical layer
    type: str
    value: STANAG_4285
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '1'
    grid: 'True'
    gui_hint: (3,3,2,3)
    label1: descrambled symbols
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1
    label1: arg(symbol)
    name: '"arg(descrambled symbol)"'
    ncols: frame_len_symb
    nrows: '100'
    samp_rate: samp_rate/sps
    type: float
    zmax: pi
    zmin: '-pi'
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@3
    name: '"abs(adaptive filter taps)"'
    ncols: (1+(nB+nF)*sps)
    nrows: '100'
    samp_rate: samp_rate
    type: float
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@4:0,0,1,1
    label1: '""'
    name: '"bits"'
    ncols: frame_len_bits_range
    nrows: '100'
    samp_rate: samp_rate/sps
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (3,0,1,3)
    label1: preamble cross-correlation
    legend: 'False'
    size: 80*sps
    srate: samp_rate
    tr_delay: '0.007'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"time_est"'
    type: float
    update_time: '.1'
    ylabel: preamble correlation
    ymax: '1000'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@2
    label1: ''
    legend: 'False'
    srate: samp_rate/sps/2
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: msg_float
    ylabel: Soft Decision LLR
    ymax: '7'
    ymin: '-7'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    gui_hint: tab@0
    int_min: '-80'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '12000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Sampler per Symbol
    value: '5'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,2,6
    label0: I/Q Waterfall
    label1: Descrambled Symbols
    label2: Soft Decisions
    label3: Adaptive Filter Taps
    label4: Bit Stream
    num_tabs: '5'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: symbols
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_raster_sink_x_0_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_1, '0']
- [blocks_complex_to_magphase_0, '1', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', virtual_sink_1, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', pad_sink_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_1, '0']
- [digitalhf_physical_layer_driver_0, '0', qtgui_const_sink_x_0, '0']
- [digitalhf_physical_layer_driver_0, '0', virtual_sink_3, '0']
- [digitalhf_physical_layer_driver_0, '1', blocks_complex_to_mag_0, '0']
- [digitalhf_physical_layer_driver_0, '2', blocks_vector_to_stream_0, '0']
- [digitalhf_physical_layer_driver_0, bits, bits_msg_sink, in]
- [digitalhf_physical_layer_driver_0, bits, blocks_pdu_to_tagged_stream_0, pdus]
- [digitalhf_physical_layer_driver_0, soft_dec, blocks_pdu_to_tagged_stream_0_0, pdus]
- [digitalhf_physical_layer_driver_0, soft_dec, qtgui_time_sink_x_1, in]
- [pad_source_0, '0', digitalhf_physical_layer_driver_0, '0']
- [pad_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1, '0', pad_sink_0, '0']
- [virtual_source_1, '0', qtgui_time_raster_sink_x_0_1, '0']
- [virtual_source_2, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_2, '0', pad_sink_0_0, '0']

metadata:
  file_format: 1
