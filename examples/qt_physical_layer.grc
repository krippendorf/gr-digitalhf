<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>qt_pysical_layer</value></param>
<param><key>category</key><value>[digitalhf]</value></param>
<param><key>description</key><value>physical_layer_driver + QT interface</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
<param><key>title</key><value>QT physical layer driver</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>doppler</value></param>
<param><key>block_id</key><value>digitalhf_physical_layer_driver_0</value></param>
<param><key>function_name</key><value>get_doppler</value></param>
<param><key>value</key><value>'UNKNOWN'</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frame_len_bits_range</value></param>
<param><key>value</key><value>frame_len_bits</value></param>
<param><key>gui_hint</key><value>tab@4:1,0,1,1</value></param>
<param><key>label</key><value>frame length</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>4096</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_doppler</value></param>
<param><key>value</key><value>doppler</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>label</key><value>Doppler</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_mode</value></param>
<param><key>value</key><value>mode_for_display</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>label</key><value>Mode</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_quality</value></param>
<param><key>value</key><value>quality</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Quality</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>mode_for_display</value></param>
<param><key>block_id</key><value>digitalhf_physical_layer_driver_0</value></param>
<param><key>function_name</key><value>get_mode</value></param>
<param><key>value</key><value>"____"</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>gui_hint</key><value>(4,0,1,3)</value></param>
<param><key>label</key><value>mu</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0001</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>0.01</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>quality</value></param>
<param><key>block_id</key><value>digitalhf_physical_layer_driver_0</value></param>
<param><key>function_name</key><value>get_quality</value></param>
<param><key>value</key><value>'UNKNOWN'</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>bits_msg_sink</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>bits_msg</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
</block>
<block>
<key>blocks_complex_to_magphase</key>
<param><key>id</key><value>blocks_complex_to_magphase_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>exp(0.4j)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>(1+(nB+nF)*sps)</value></param>
</block>
<block>
<key>digitalhf_physical_layer_driver</key>
<param><key>id</key><value>digitalhf_physical_layer_driver_0</value></param>
<param><key>description_name</key><value>physical_layer_type</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>mode</key><value>physical_layer_mode</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>nB</key><value>nB</value></param>
<param><key>nF</key><value>nF</value></param>
<param><key>nW</key><value>nW</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len_bits</value></param>
<param><key>label</key><value>frame length bits</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len_symb</value></param>
<param><key>label</key><value>frame length  symbols</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from numpy import exp, pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nB</value></param>
<param><key>label</key><value>nB</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nF</value></param>
<param><key>label</key><value>nF</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nW</value></param>
<param><key>label</key><value>nW</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>bits</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>symbols</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>soft_dec</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>I/Q input</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>physical_layer_mode</value></param>
<param><key>label</key><value>mode for physical layer</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"600/L"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>physical_layer_type</value></param>
<param><key>label</key><value>Type of physical layer</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>STANAG_4285</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>(3,3,2,3)</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>label1</key><value>descrambled symbols</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmax</key><value>pi</value></param>
<param><key>zmin</key><value>-pi</value></param>
<param><key>label1</key><value>arg(symbol)</value></param>
<param><key>name</key><value>"arg(descrambled symbol)"</value></param>
<param><key>ncols</key><value>frame_len_symb</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate/sps</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>name</key><value>"abs(adaptive filter taps)"</value></param>
<param><key>ncols</key><value>(1+(nB+nF)*sps)</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>tab@4:0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>label1</key><value>""</value></param>
<param><key>name</key><value>"bits"</value></param>
<param><key>ncols</key><value>frame_len_bits_range</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate/sps</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>(3,0,1,3)</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>preamble cross-correlation</value></param>
<param><key>size</key><value>80*sps</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.007</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"time_est"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>.1</value></param>
<param><key>ylabel</key><value>preamble correlation</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>srate</key><value>samp_rate/sps/2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"packet_len"</value></param>
<param><key>type</key><value>msg_float</value></param>
<param><key>ylabel</key><value>Soft Decision LLR</value></param>
<param><key>ymax</key><value>7</value></param>
<param><key>ymin</key><value>-7</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>int_min</key><value>-80</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>12000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Sampler per Symbol</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>1,0,2,6</value></param>
<param><key>label0</key><value>I/Q Waterfall</value></param>
<param><key>label1</key><value>Descrambled Symbols</value></param>
<param><key>label2</key><value>Soft Decisions</value></param>
<param><key>label3</key><value>Adaptive Filter Taps</value></param>
<param><key>label4</key><value>Bit Stream</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>bits</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_magphase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>bits_msg_sink</sink_block_id><source_key>bits</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>bits</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>soft_dec</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>soft_dec</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>digitalhf_physical_layer_driver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
